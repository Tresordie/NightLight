# Keil uVision project nightlight.uvprojx, settings and files
target v03 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nightlight +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\bsp;..\User\bsp\inc;..\User\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group cmsis
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group stdlib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group bsp
    ../User/bsp/: bsp.c
    ../User/bsp/src/: bsp_gpio.c bsp_key.c bsp_led.c bsp_nvic.c bsp_pwmout.c bsp_timbase.c bsp_uart.c bsp_hs.c bsp_adc.c bsp_sw_delay.c
  group app
    ../User/app/src/: main.c buzzer.c Adafruit_NeoPixel.c ws2812fx.c
    ../User/bsp/: stm32f10x_it.c
